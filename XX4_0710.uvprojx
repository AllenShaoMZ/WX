# Keil uVision project XX4_0710.uvprojx, settings and files
target Cortex-M3 Flash (5050106::V5.05 update 1 (build 106)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: XX4_0710 +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: MSS_CAN_ENABLE_INTERRUPTS MSS_CAN_USER_ISR
  c misc: --c99
  c include: ./;.\App;./CMSIS;./CMSIS/startup_arm;./drivers;.\drivers\mss_gpio;./drivers/mss_hpdma;./drivers/mss_nvm;./drivers/mss_pdma;./drivers/mss_sys_services;.\drivers\mss_timer;.\drivers\mss_uart;.\drivers\mss_watchdog;./drivers_config;./drivers_config/sys_config;./hal;./hal/CortexM3;./hal/CortexM3/Keil;.\head;.\drivers\mss_can;.\drivers\mss_spi;C:\Users\Administrator\AppData\Local\Arm\Packs\ARM\CMSIS\5.8.0\CMSIS\Core\Include;.\source;.\MidWares;.\MidWares\uCOS3\uC-CPU\Cfg\Template;.\MidWares\uCOS3\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;.\MidWares\uCOS3\uC-CPU;.\MidWares\uCOS3\uC-LIB\Cfg\Template;.\MidWares\uCOS3\uC-LIB;.\MidWares\uCOS3\uC-OS3\Cfg\Template;.\MidWares\uCOS3\uC-OS3\Ports\ARM-Cortex-M\ARMv7-M\ARM;.\MidWares\uCOS3\uC-OS3\Source;.\MidWares\uCOS3\uC-CPU\BSP\Template;..\Packs\ARM\CMSIS\5.8.0\CMSIS\Core\Include;.\SYSTEM;D:\soft\Keil_v5\ArmPacks\ARM\CMSIS\5.8.0\CMSIS\Core\Include;..\..\Packs\ARM\CMSIS\5.8.0\CMSIS\Core\Include
  asm include: ./;./CMSIS;./CMSIS/startup_arm;./drivers;./drivers/mss_gpio;./drivers/mss_hpdma;./drivers/mss_nvm;./drivers/mss_pdma;./drivers/mss_sys_services;./drivers/mss_timer;./drivers/mss_uart;./drivers/mss_watchdog;./drivers_config;./drivers_config/sys_config;./hal;./hal/CortexM3;./hal/CortexM3/Keil
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ./CMSIS/startup_arm/: startup_m2sxxx.s retarget.c
    ./CMSIS/: system_m2sxxx.c
  group Head Files
    ./head/: include.h define.h typedef.h extern.h FPGAUart.h FPGACan.h can.h
    ./: time.h main.h memory.h flyprog.h yc_init.h RS422.h tc.h program_control.h
  group Source Files
    ./source/: main.c basic.c extern.c FPGAUart.c FPGACan.c can.c
    ./: time.c memory.c flyprog.c RS422.c tc.c program_control.c
  group Library Files
    ./Objects/: M2S050T_MSS_CM3_hw_platform.lib
  group MidWares/uCOS3/BSP
    ./MidWares/uCOS3/uC-CPU/BSP/Template/: bsp_cpu.c
    ./MidWares/uCOS3/uC-OS3/Template/: bsp_os_dt.c
  group MidWares/uCOS3/CPU
    ./MidWares/uCOS3/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ./MidWares/uCOS3/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
    ./MidWares/uCOS3/uC-CPU/: cpu_core.c
  group MidWares/uCOS3/LIB
    ./MidWares/uCOS3/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group MidWares/uCOS3/OS3
    ./MidWares/uCOS3/uC-OS3/Cfg/Template/: os_app_hooks.c
    ./MidWares/uCOS3/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ./MidWares/uCOS3/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm
    ./MidWares/uCOS3/uC-OS3/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
